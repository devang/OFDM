<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>kiss_tx_ofdm</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>base_freq</value></param>
<param><key>value</key><value>525e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>variable_qtgui_range_1</value></param>
<param><key>value</key><value>25</value></param>
<param><key>label</key><value>Gain slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/send.file</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>.05</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>kiss_ofdm_tx_stream</key>
<param><key>id</key><value>kiss_ofdm_tx_stream_0</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>freq0</key><value>base_freq</value></param>
<param><key>if_gain0</key><value>variable_qtgui_range_1</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value>hackrf=0000000000000000a06063c8220a765f</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>base_freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>fft_len</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>tx_bits</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>(fft_len-(fft_len/4))*50000</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>kiss_ofdm_tx_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiss_ofdm_tx_stream_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tx_bits</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tx_bits</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
